#@DESCRPITION: Change to a specify version of reterminal

SRCREV = "589dab165f7a55eec0cc5fa25cc0bf892f4aa52c"

SRC_URI = "git://github.com/Seeed-Studio/seeed-linux-dtoverlays.git;protocol=https;nobranch=1;tag=589dab165f7a55eec0cc5fa25cc0bf892f4aa52c \
        file://0001-compatible-for-yocto.patch \
        "

